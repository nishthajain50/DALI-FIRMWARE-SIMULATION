# Keil uVision project DALI_SIM.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: LKS32AT037PXL5M6Q9 Linko
  pack: Linko.LKS03x.1.1.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DALI_SIM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: hardware_sim.h dali_machine_sim.h dali_machine_sim.c dali_protocol_sim.h dali_protocol_sim.c led_dimmer_sim.h led_dimmer_sim.c memory.h memory.c main.c
    ../LKS/: startup_lks32mc03x.s
